# IAR project Gold_Razor_A_K60DZ10.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: LPLD_K60; USE_K60DZ10
  ICCARM.CCIncludePath2: ..\app; ..\app\Source; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Gold_Razor_A_K60DZ10.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_BOOT.icf
  group app
    ../app/: Gold_Razor_A.c k60_card.h
  group app/Source
    ../app/Source/: DebugerDriver.c DebugerDriver.h Eagle_ov7725.c Eagle_ov7725.h Eagle_ov7725_reg.h EncoderDriver.c EncoderDriver.h ImgProcess.c ImgProcess.h Menu.c Menu.h MotorDriver.c MotorDriver.h oled.c oled.h oledfont.h PID.c PID.h SequenceCtrl.c SequenceCtrl.h SteerDriver.c SteerDriver.h VirtualOsc.c VirtualOsc.h
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: startup_K60DZ10.s system_MK60.c
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/DEV
    ../../../lib/LPLD/DEV/: DEV_SCCB.c DEV_SCCB.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_DMA.c HW_DMA.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PIT.c HW_PIT.h HW_UART.c HW_UART.h
